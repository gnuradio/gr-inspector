options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: signal_detection
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '3200'
    step: '10'
    stop: '12700'
    value: '9800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '12700'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '3200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '10000000'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: 10-4
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '100000000'
    fft_len: '4096'
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: '4096'
    logfile: ''
    min_bw: '10'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: '0.9'
    threshold: '-20'
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', inspector_signal_detector_cvf_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]

metadata:
  file_format: 1
