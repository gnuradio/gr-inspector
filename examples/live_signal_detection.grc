<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>live_signal_detection</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>thres</value></param>
<param><key>value</key><value>-65</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>inspector_qtgui_sink_vf</key>
<param><key>id</key><value>inspector_qtgui_sink_vf_0</value></param>
<param><key>cfreq</key><value>0</value></param>
<param><key>fft_len</key><value>4096</value></param>
<param><key>manual</key><value>False</value></param>
<param><key>msgports</key><value>1</value></param>
<param><key>rf_unit</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>inspector_signal_detector_cvf</key>
<param><key>id</key><value>inspector_signal_detector_cvf_0</value></param>
<param><key>auto</key><value>False</value></param>
<param><key>avg</key><value>0.005</value></param>
<param><key>fft_len</key><value>4096</value></param>
<param><key>min_bw</key><value>10000</value></param>
<param><key>quant</key><value>0.001</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value> 0.2</value></param>
<param><key>threshold</key><value>thres</value></param>
<param><key>window</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>40</value></param>
<param><key>freq0</key><value>101669000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>inspector_qtgui_sink_vf_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>map_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>inspector_signal_detector_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
