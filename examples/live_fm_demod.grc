options:
  parameters:
    generate_options: qt_gui
    id: live_fm_demod
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 90e6
    step: '10000'
    stop: 110e6
    value: 101.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    deemph_tau: '75e-6'
    quad_rate: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '0'
    fft_len: '1024'
    manual: 'True'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.8'
    fft_len: ' 1024'
    logfile: ''
    min_bw: '5000'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: ' 0.2'
    threshold: '-50'
    window: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: inspector_signal_extractor_c_0
  id: inspector_signal_extractor_c
  parameters:
    osf: '1'
    rate: '96000'
    resample: 'True'
    signal: '0'
  states: {}
- name: inspector_signal_separator_c_0
  id: inspector_signal_separator_c
  parameters:
    file: 'False'
    oversample: '1.0'
    samp_rate: samp_rate
    taps_file: ''
    trans_width: '0.1'
    window: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [inspector_qtgui_sink_vf_0, map_out, inspector_signal_separator_c_0, map_in]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [inspector_signal_extractor_c_0, '0', analog_wfm_rcv_0, '0']
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_0, sig_in]
- [soapy_rtlsdr_source_0, '0', inspector_signal_detector_cvf_0, '0']
- [soapy_rtlsdr_source_0, '0', inspector_signal_separator_c_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-73-ga44ffb7b
