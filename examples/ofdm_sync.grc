options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ofdm_sync
    output_language: python
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '15'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '50'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: 1765/samp_rate
    noise_voltage: '0'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: (list(range(-128//2,0))+list(range(1,128//2)),)
    packet_len_key: length
    payload_mod: '"BPSK"'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    rolloff: '0'
    sync_word1: ([0] * fft_len)
  states: {}
- name: inspector_ofdm_synchronizer_cc_0
  id: inspector_ofdm_synchronizer_cc
  parameters:
    min_items: '4096'
  states: {}
- name: inspector_ofdm_zkf_c_0
  id: inspector_ofdm_zkf_c
  parameters:
    alpha: '[16, 32, 64, 128, 256, 512, 1024]'
    beta: '[4, 8, 16, 32, 64]'
    min_items: '7000'
    samp_rate: samp_rate
    signal: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1000'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"symbol"'
    type: complex
    update_time: '0.5'
    ymax: '100'
    ymin: '-100'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    minoutbuf: '256'
    taps: '1'
    type: ccc
  states: {state: bypassed}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [channels_channel_model_0, '0', inspector_ofdm_synchronizer_cc_0, '0']
- [channels_channel_model_0, '0', inspector_ofdm_zkf_c_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_ofdm_tx_0, '0', blocks_throttle_0, '0']
- [inspector_ofdm_synchronizer_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [inspector_ofdm_synchronizer_cc_0, '0', qtgui_time_sink_x_0, '0']
- [inspector_ofdm_zkf_c_0, ofdm_out, inspector_ofdm_synchronizer_cc_0, ofdm_in]
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
