<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.8.git'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>recorder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfreq</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>signal0.c32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>signal1.c32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>signal2.c32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>inspector_qtgui_sink_vf</key>
<param><key>id</key><value>inspector_qtgui_sink_vf_0</value></param>
<param><key>cfreq</key><value>cfreq</value></param>
<param><key>fft_len</key><value>1024</value></param>
<param><key>manual</key><value>False</value></param>
<param><key>msgports</key><value>1</value></param>
<param><key>rf_unit</key><value>1000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>inspector_signal_detector_cvf</key>
<param><key>id</key><value>inspector_signal_detector_cvf_0</value></param>
<param><key>auto</key><value>False</value></param>
<param><key>avg</key><value>0.2</value></param>
<param><key>fft_len</key><value> 1024</value></param>
<param><key>min_bw</key><value>300</value></param>
<param><key>quant</key><value>0.0001</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>0.8</value></param>
<param><key>threshold</key><value>-95</value></param>
<param><key>window</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>inspector_signal_extractor_c</key>
<param><key>id</key><value>inspector_signal_extractor_c_0</value></param>
<param><key>rate</key><value>output_samp_rate</value></param>
<param><key>osf</key><value>2</value></param>
<param><key>resample</key><value>True</value></param>
<param><key>signal</key><value>0</value></param>
</block>
<block>
<key>inspector_signal_extractor_c</key>
<param><key>id</key><value>inspector_signal_extractor_c_1</value></param>
<param><key>rate</key><value>output_samp_rate</value></param>
<param><key>osf</key><value>2</value></param>
<param><key>resample</key><value>True</value></param>
<param><key>signal</key><value>1</value></param>
</block>
<block>
<key>inspector_signal_extractor_c</key>
<param><key>id</key><value>inspector_signal_extractor_c_2</value></param>
<param><key>rate</key><value>output_samp_rate</value></param>
<param><key>osf</key><value>2</value></param>
<param><key>resample</key><value>True</value></param>
<param><key>signal</key><value>2</value></param>
</block>
<block>
<key>inspector_signal_separator_c</key>
<param><key>id</key><value>inspector_signal_separator_c_0</value></param>
<param><key>oversample</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps_file</key><value></value></param>
<param><key>trans_width</key><value>0.1</value></param>
<param><key>file</key><value>False</value></param>
<param><key>window</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>cfreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>inspector_qtgui_sink_vf_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_extractor_c_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_extractor_c_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_extractor_c_2</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_separator_c_0</source_block_id><sink_block_id>inspector_signal_extractor_c_0</sink_block_id><source_key>sig_out</source_key><sink_key>sig_in</sink_key></connection>
<connection><source_block_id>inspector_signal_separator_c_0</source_block_id><sink_block_id>inspector_signal_extractor_c_1</sink_block_id><source_key>sig_out</source_key><sink_key>sig_in</sink_key></connection>
<connection><source_block_id>inspector_signal_separator_c_0</source_block_id><sink_block_id>inspector_signal_extractor_c_2</sink_block_id><source_key>sig_out</source_key><sink_key>sig_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>inspector_signal_detector_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
