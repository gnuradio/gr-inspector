options:
  parameters:
    generate_options: qt_gui
    id: recorder
    output_language: python
  states: {}

blocks:
- name: cfreq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: output_samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: signal0.c32
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: signal1.c32
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: signal2.c32
    type: complex
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: cfreq
    fft_len: '1024'
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: ' 1024'
    logfile: ''
    min_bw: '300'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: '0.8'
    threshold: '-95'
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: inspector_signal_extractor_c_0
  id: inspector_signal_extractor_c
  parameters:
    osf: '2'
    rate: output_samp_rate
    resample: 'True'
    signal: '0'
  states: {}
- name: inspector_signal_extractor_c_1
  id: inspector_signal_extractor_c
  parameters:
    osf: '2'
    rate: output_samp_rate
    resample: 'True'
    signal: '1'
  states: {}
- name: inspector_signal_extractor_c_2
  id: inspector_signal_extractor_c
  parameters:
    osf: '2'
    rate: output_samp_rate
    resample: 'True'
    signal: '2'
  states: {}
- name: inspector_signal_separator_c_0
  id: inspector_signal_separator_c
  parameters:
    file: 'False'
    oversample: '2'
    samp_rate: samp_rate
    taps_file: ''
    trans_width: '0.1'
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: cfreq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [inspector_qtgui_sink_vf_0, map_out, inspector_signal_separator_c_0, map_in]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [inspector_signal_extractor_c_0, '0', blocks_file_sink_0, '0']
- [inspector_signal_extractor_c_1, '0', blocks_file_sink_0_0, '0']
- [inspector_signal_extractor_c_2, '0', blocks_file_sink_0_1, '0']
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_0, sig_in]
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_1, sig_in]
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_2, sig_in]
- [uhd_usrp_source_0, '0', inspector_signal_detector_cvf_0, '0']
- [uhd_usrp_source_0, '0', inspector_signal_separator_c_0, '0']

metadata:
  file_format: 1
