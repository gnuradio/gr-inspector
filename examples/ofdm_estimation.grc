options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ofdm_estimation
    output_language: python
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '5'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '50'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '6400'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '0.8'
    freq_offset: '0'
    noise_voltage: numpy.sqrt(10**(-SNR/10.0))
    seed: '0'
    taps: numpy.random.rand(1) + 1j*numpy.random.rand(1)
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: (list(range(-128//2,0))+list(range(1,128//2)),)
    packet_len_key: length
    payload_mod: '"BPSK"'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    rolloff: '0'
    sync_word1: ([0] * fft_len)
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: inspector_ofdm_zkf_c_0
  id: inspector_ofdm_zkf_c
  parameters:
    alpha: '[16, 32, 64, 128, 256, 512, 1024]'
    beta: '[4, 8, 16, 32, 64]'
    min_items: '7000'
    samp_rate: samp_rate
    signal: '0'
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '0'
    fft_len: '1024'
    manual: 'True'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.8'
    fft_len: ' 1024'
    logfile: ''
    min_bw: '10000'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: ' 0.9'
    threshold: '-35'
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', inspector_ofdm_zkf_c_0, '0']
- [channels_channel_model_0, '0', inspector_signal_detector_cvf_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_tx_0, '0', blocks_throttle_0, '0']
- [inspector_ofdm_zkf_c_0, ofdm_out, inspector_qtgui_sink_vf_0, analysis_in]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]

metadata:
  file_format: 1
