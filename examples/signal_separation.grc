options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: signal_separation
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: sig
  id: variable
  parameters:
    value: '0'
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '-120'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '9800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '12700'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '3200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: 10-4
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '3200'
    decim: samp_rate//32//100
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1440, 144, firdes.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '100000000'
    fft_len: '4096'
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: '4096'
    logfile: ''
    min_bw: '10'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: '0.8'
    threshold: thres
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: inspector_signal_extractor_c_0
  id: inspector_signal_extractor_c
  parameters:
    osf: '1'
    rate: '48000'
    resample: 'False'
    signal: '0'
  states: {}
- name: inspector_signal_separator_c_0
  id: inspector_signal_separator_c
  parameters:
    file: 'False'
    oversample: '100'
    samp_rate: samp_rate
    taps_file: /home/senpo/src/gr-inspector/apps/taps.json
    trans_width: '0.1'
    window: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 32*100
    fc: '0'
    fftsize: '1024'
    label1: Signal  Separator
    label2: Xlating FIR
    name: '"Extracted Signal " + str(sig+1)'
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', inspector_signal_detector_cvf_0, '0']
- [blocks_throttle_0, '0', inspector_signal_separator_c_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [inspector_qtgui_sink_vf_0, map_out, inspector_signal_separator_c_0, map_in]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [inspector_signal_extractor_c_0, '0', qtgui_freq_sink_x_0, '0']
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_0, sig_in]

metadata:
  file_format: 1
