<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>L</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Np</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>thres</value></param>
<param><key>value</key><value>-90</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>44100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>44100*2</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>44100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>44100*5</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>comment</key><value>We need to pass a 1D
vector to the 3D visualiser, 
the FAM block outputs a number 
of 1D vectors, which together, 
make up a 2D represention of
FAM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>2 * P * L * 2 * Np</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>2*Np</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/music2.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/music2.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_symbol</key><value>sym</value></param>
<param><key>sensitivity</key><value>1.0</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_symbol</key><value>sym</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>samples_per_symbol</key><value>sym</value></param>
</block>
<block>
<key>digital_qam_mod</key>
<param><key>id</key><value>digital_qam_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>16</value></param>
<param><key>samples_per_symbol</key><value>sym</value></param>
</block>
<block>
<key>digital_qam_mod</key>
<param><key>id</key><value>digital_qam_mod_0_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>64</value></param>
<param><key>samples_per_symbol</key><value>sym</value></param>
</block>
<block>
<key>inspector_qtgui_sink_vf</key>
<param><key>id</key><value>inspector_qtgui_sink_vf_0</value></param>
<param><key>cfreq</key><value>100000000</value></param>
<param><key>fft_len</key><value>4096</value></param>
<param><key>manual</key><value>False</value></param>
<param><key>msgports</key><value>1</value></param>
<param><key>rf_unit</key><value>1000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>inspector_signal_detector_cvf</key>
<param><key>id</key><value>inspector_signal_detector_cvf_0</value></param>
<param><key>auto</key><value>False</value></param>
<param><key>avg</key><value>0.2</value></param>
<param><key>fft_len</key><value>4096</value></param>
<param><key>min_bw</key><value>10</value></param>
<param><key>quant</key><value>0.001</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>0.8</value></param>
<param><key>threshold</key><value>thres</value></param>
<param><key>window</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>inspector_signal_extractor_c</key>
<param><key>id</key><value>inspector_signal_extractor_c_0</value></param>
<param><key>rate</key><value>48000</value></param>
<param><key>osf</key><value>1</value></param>
<param><key>resample</key><value>False</value></param>
<param><key>signal</key><value>0</value></param>
</block>
<block>
<key>inspector_signal_separator_c</key>
<param><key>id</key><value>inspector_signal_separator_c_0</value></param>
<param><key>oversample</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps_file</key><value>/home/senpo/src/gr-inspector/apps/taps.json</value></param>
<param><key>trans_width</key><value>0.1</value></param>
<param><key>file</key><value>False</value></param>
<param><key>window</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>inspector_tfmodel_vcf</key>
<param><key>id</key><value>inspector_tfmodel_vcf_0</value></param>
<param><key>graphfile</key><value>/tmp/fam/00000001</value></param>
<param><key>typev</key><value>float</value></param>
<param><key>reshape</key><value>(2*P*L,2*Np)</value></param>
<param><key>vlen</key><value>2 * P * L * 2 * Np</value></param>
</block>
<block>
<key>specest_cyclo_fam</key>
<param><key>id</key><value>specest_cyclo_fam_0</value></param>
<param><key>Np</key><value>Np</value></param>
<param><key>L</key><value>L</value></param>
<param><key>P</key><value>P</value></param>
</block>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_qam_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_qam_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>inspector_tfmodel_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>inspector_signal_detector_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_mod_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_qtgui_sink_vf_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_extractor_c_0</source_block_id><sink_block_id>specest_cyclo_fam_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_separator_c_0</source_block_id><sink_block_id>inspector_signal_extractor_c_0</sink_block_id><source_key>sig_out</source_key><sink_key>sig_in</sink_key></connection>
<connection><source_block_id>inspector_tfmodel_vcf_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>classification</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>inspector_tfmodel_vcf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>classification</source_key><sink_key>analysis_in</sink_key></connection>
<connection><source_block_id>specest_cyclo_fam_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
